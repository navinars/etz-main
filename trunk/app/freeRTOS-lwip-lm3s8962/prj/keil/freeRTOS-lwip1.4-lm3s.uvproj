# Keil uVision project freeRTOS-lwip1.4-lm3s.uvproj, settings and files
target freeRTOS-lwip1.4 (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: freeRTOS-lwip-lm3s
  c flags: Optim=1
  c define: rvmdk PART_LM3S8962
  c include: ..\..\src\app;..\..\src\bsp;..\..\src\drv;..\..\src\net;..\..\src\os\freeRTOS_7.1.0\include;..\..\src\third_party\lwip-1.4.0\src\include;..\..\src\third_party\lwip-1.4.0\src\include\ipv4;..\..\src\third_party\lwip-1.4.0\ports\stellaris\netif;..\..\src\third_party\lwip-1.4.0\ports\stellaris\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../src/app/: main.c app_cfg.h includes.h Startup.s
  group Bsp
    ../../src/bsp/: bsp.c bsp_led.c rit128x96x4.c
  group Drv
    ../../src/drv/driverlib/: cpu.c ethernet.c gpio.c interrupt.c hibernate.c sysctl.c ssi.c timer.c uart.c
  group Utils
    ../../src/drv/utils/: locator.c lwiplib.c ustdlib.c uartstdio.c
  group Net
    ../../src/net/: network.c
  group lwIP
    ../../src/third_party/lwip-1.4.0/ports/stellaris/: sys_arch.c perf.c
    ../../src/third_party/lwip-1.4.0/ports/stellaris/netif/: stellarisif.c
    ../../src/third_party/lwip-1.4.0/src/netif/: etharp.c ethernetif.c slipif.c
  group lwIP-api
    ../../src/third_party/lwip-1.4.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP-core
    ../../src/third_party/lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwIP-IPv4
    ../../src/third_party/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group freeRTOS
    ../../src/os/freeRTOS_7.1.0/: heap_2.c list.c port.c queue.c tasks.c
    ../../src/os/freeRTOS_7.1.0/include/: FreeRTOSConfig.h
