<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\cc1101_rcv.ewp</path>
  </project>
  <batchBuild/>
</workspace>


