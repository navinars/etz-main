# Keil uVision project host_lm3s8962.uvproj, settings and files
target lwIP-1.40 uC/OS-2.89 (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lm3s8962_cc2520
  c flags: Optim=1
  c define: rvmdk PART_LM3S8962
  c include: ..\..\src\app;..\..\src\drv;..\..\src\bsp;..\..\src\net;..\..\src\os\uCOS-II;..\..\src\os\uCOS-II\Ports;..\..\src\os\uC-LIB;..\..\src\lwip-1.4.0;..\..\src\lwip-1.4.0\src\include;..\..\src\lwip-1.4.0\src\include\ipv4;..\..\src\lwip-1.4.0\ports\stellaris\include;..\..\src\lwip-1.4.0\ports\stellaris\netif
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group APP
    ../../src/app/: app.c app_cfg.h includes.h os_cfg.h Startup.s
  group BSP
    ../../src/bsp/: bsp.c bsp_led.c rit128x96x4.c
  group LIB
    ../../src/drv/driverlib/: adc.c can.c comp.c cpu.c eeprom.c epi.c ethernet.c fan.c flash.c fpu.c gpio.c hibernate.c i2c.c i2s.c interrupt.c lpc.c mpu.c peci.c pwm.c qei.c ssi.c sysctl.c sysexc.c systick.c timer.c uart.c watchdog.c
  group Utils
    ../../src/drv/utils/: ustdlib.c
  group NET
    ../../src/net/: network.c ping.c
    ../../src/drv/utils/: lwiplib.c
  group lwIP
    ../../src/lwip-1.4.0/ports/stellaris/: perf.c sys_arch.c
    ../../src/lwip-1.4.0/ports/stellaris/netif/: stellarisif.c
    ../../src/lwip-1.4.0/src/netif/: etharp.c slipif.c
  group lwIP-api
    ../../src/lwip-1.4.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP-core
    ../../src/lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwIP-IPv4
    ../../src/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group uC/OS-II Port
    ../../src/os/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC/OS-II Source
    ../../src/os/uCOS-II/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
