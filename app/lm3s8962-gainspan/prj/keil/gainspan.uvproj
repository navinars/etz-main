# Keil uVision project gainspan.uvproj, settings and files
target GainSpan (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gainspan
  c include: ..\..\drv;..\..\bsp\gainspan;..\..\bsp\user;..\..\app
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: Startup.s
  group App
    ../../app/: main.c includes.h
  group Driver
    ../../drv/driverlib/: cpu.c sysctl.c uart.c gpio.c interrupt.c ssi.c timer.c
  group GainSpan
    ../../bsp/gainspan/: AtCmdLib.c gp_cmd.c
  group Utils
    ../../drv/user/: rit128x96x4.c
    ../../bsp/user/: util_uart.c util_timer.c bsp_led.c
    ../../drv/utils/: uartstdio.c
