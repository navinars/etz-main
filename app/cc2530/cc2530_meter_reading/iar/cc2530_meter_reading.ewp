# IAR project cc2530_meter_reading.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F128.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../src/app; ../src/mcu; ../src/common; ../src/util; ../src/mac; ../src/bsp
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F128.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group APP
    ../src/app/: chipcon_cstartup.s51 includes.h main.c
  group BSP
    ../src/bsp/: mtreading.c mtreading.h
  group COMMON
    ../src/common/: hal_cc8051.h hal_defs.h hal_types.h
  group MAC
    ../src/mac/: mac.c mac.h mac_buf.c mac_gen.c mac_hw.c mac_parse.c
  group MCU
    ../src/mcu/: hal_adc.c hal_adc.h hal_assert.c hal_assert.h hal_board.c hal_board.h hal_clock.c hal_clock.h hal_digio.c hal_digio.h hal_flash.c hal_flash.h hal_int.c hal_int.h hal_led.c hal_led.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_timer.c hal_timer.h hal_uart.c hal_uart.h sfr-bits.h
  group UTIL
    ../src/util/: util.c util.h util_buffer.c util_buffer.h util_timer.c util_timer.h
