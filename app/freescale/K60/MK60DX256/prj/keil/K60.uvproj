# Keil uVision project K60.uvproj, settings and files
target lwIP1.4_MK60 (ARM-ADS)
  device: MK60DX256xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: K60
  c flags: Optim=2 OneElfS=1
  c define: KEIL FREEDOM CMSIS K60DX256
  c include: ..\..\src\app;..\..\src\drv\common;..\..\src\drv\platforms;..\..\src\drv\drivers;..\..\src\drv\drivers\enet;..\..\src\os\uCOS-II;..\..\src\os\uC-LIB;..\..\src\os\uC-CPU;..\..\src\os\uCOS-II\Ports;..\..\src\os\uC-CPU\ARM-Cortex-M4\IAR;..\..\src\lwip-1.4.0\ports\kinetis;..\..\src\lwip-1.4.0\src\include;..\..\src\lwip-1.4.0\src\include\ipv4;..\..\src\lwip-1.4.0\ports
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../src/app/: system_MK60DZ10.c startup_MK60DZ10.s MemMapPtr_MK60DZ10.h
  group App
    ../../src/app/: app.c app_cfg.h os_cfg.h
  group Cpu
    ../../src/drv/common/: common.h printf.c stdlib.c uif.c alloc.c assert.c queue.c io.c
    ../../src/drv/drivers/: arm_cm4.c
  group Drv
    ../../src/drv/drivers/: sysinit.c adc16.c mcg.c pmc.c rtc.c uart.c wdog.c lptmr.c
  group Enet
    ../../src/drv/drivers/enet/: enet.c eth_phy.c mii.c nbuf.c
  group lwIP-arch
    ../../src/lwip-1.4.0/ports/kinetis/: etharp.c ethernetif.c sys_arch.c
  group lwIP-api
    ../../src/lwip-1.4.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP-core
    ../../src/lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwIP-IPv4
    ../../src/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group uCOS-II Port
    ../../src/os/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uCOS-II Source
    ../../src/os/uCOS-II/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
