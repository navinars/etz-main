# IAR project smoke.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2433 MSP430G2433
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\src\app; ..\src\bsp; ..\src\lib; ..\src\Radio; ..\src\Radio\CC1101; ..\src\Radio\Si4455
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2433.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group APP
    ../src/app/: hal_defs.h hal_types.h main.c radio.c radio.h radio_config.h
  group BSP
    ../src/bsp/: bsp.h
  group LIB
    ../src/lib/: gpio.c gpio.h int.h msp430_a.s43 spi.c spi.h timer.c timer.h
  group Radio
    ../src/radio/: cc1101_defs.h cc1101_handle.c cc1101_port.c cc1101_port.h cc1101_radio.c cc1101_radio.h radio_comm.c radio_comm.h radio_hal.c radio_hal.h radio_handle.c radio_handle.h
  group Radio/CC1101
    ../src/radio/CC1101/: Rfcc1101.h RfTranceiver.c RfTranceiver.h
  group Radio/Si4455
    ../src/radio/Si4455/: si4455_api_lib.c si4455_api_lib.h si4455_defs.h si4455_nirq.c si4455_nirq.h
