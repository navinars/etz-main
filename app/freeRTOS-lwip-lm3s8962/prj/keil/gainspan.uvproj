# Keil uVision project gainspan.uvproj, settings and files
target GainSpan (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gainspan
  c flags: Optim=1
  c include: ..\..\src\app;..\..\src\bsp;..\..\src\drv;..\..\src\freeRTOS\include;..\..\src\third_party\lwip-1.3.2\src\include;..\..\src\third_party\lwip-1.3.2\ports\stellaris\include;..\..\src\third_party\lwip-1.3.2\src\include\ipv4;..\..\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../src/app/: main.c app_cfg.h includes.h Startup.s
  group Bsp
    ../../src/bsp/: bsp_led.c rit128x96x4.c
  group Drv
    ../../src/drv/driverlib/: sysctl.c ssi.c uart.c ethernet.c gpio.c hibernate.c interrupt.c cpu.c timer.c
  group Utils
    ../../src/drv/utils/: lwiplib.c locator.c uartstdio.c ustdlib.c cmdline.c
  group freeRTOS
    ../../src/freeRTOS/: heap_2.c list.c port.c queue.c tasks.c
